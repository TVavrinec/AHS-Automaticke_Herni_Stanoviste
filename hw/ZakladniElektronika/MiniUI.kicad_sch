File: hw/ZakladniElektronika/MiniUI.kicad_sch (KiCad schematic)
At the start: 9 parts, among them SW1 SW, SW2 SW, SW3 SW, SW4 SW, SW5 SW

Commit message: WIP
Other:
- moved on the sheet: SW2, SW3
